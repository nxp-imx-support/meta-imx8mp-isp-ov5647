FILESEXTRAPATHS:prepend := "${THISDIR}/ov5647:"
  
SRC_URI += "file://0001-linux-kernel-add-new-ov5647-dtb.patch"
