FILESEXTRAPATHS:prepend := "${THISDIR}/ov5647:"


SRC_URI += "file://0001-isp-vvcam-add-ov5647.patch"  


